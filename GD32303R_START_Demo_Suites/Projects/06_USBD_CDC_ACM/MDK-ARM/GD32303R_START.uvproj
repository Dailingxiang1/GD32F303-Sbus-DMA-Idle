# Keil uVision project GD32303R_START.uvproj, settings and files
target GD32303R_START (ARM-ADS)
  device: GD32F303RG GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x080FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: cdc_acm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER GD32F30X_XD
  c misc: --c99
  c include: ..\inc;..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbd_library\usbd\Include;..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbd_library\device\Include;..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbd_library\class\device\cdc\Include;..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c gd32f30x_it.c gd32f30x_usbd_hw.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group GD32F30x_START
    ../../../Utilities/: gd32f303r_start.c
  group Startup
    ../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group USBD_Drivers
    ../../../../GD32F30x_Firmware_Library/GD32F30x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../GD32F30x_Firmware_Library/GD32F30x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../GD32F30x_Firmware_Library/GD32F30x_usbd_library/class/device/cdc/Source/: cdc_acm_core.c
  group Doc
    ../: readme.txt
